# Keil uVision project Lab9_C++.uvproj, settings and files
target Lab 9 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Lab9_C++
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup_TM4C123.s main.cpp PLL.cpp ST7735.cpp SlidePot.cpp print.s FIFO.cpp UART.cpp
